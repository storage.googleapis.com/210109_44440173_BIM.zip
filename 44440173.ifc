Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-05-21T00:11:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 21 00:11:30 2025 * Host: DESKTOP-6R5H9TJ * Database: C:\Users\FTLNinja\AppData\Local\Temp\a52087a9-c82e-4df3-a941-e1f902ed82a5\9cd03288-18ca-45a5-9f11-8215a6a7c245\ifc * Database version: 5507 * Database creation date: Wed May 21 00:11:29 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 21 00:11:30 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 21 00:11:30 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowController: 44440173(2025):44440173 Hand shower holder, 44440173(2025):44440173 Hand shower holder:307636
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0 mm
Type - General - Author: BIMStone; BIMObjectName: 44440173; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - CO2 Emissions (A1-A3): 1.91; CO2 Emissions (A4): 0.09; CO2 Emissions (C2): 0; CO2 Emissions (C3): 0; CO2 Emissions (C4): 0; CO2 Emissions (D): -0.79; ETIM Class Number: EC010132 Hand shower holder; UNSPSC Class Number: 30181800 Faucet and shower heads, jets and parts and accessories; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.hansa.com/EPD/44440173; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/196816_44440173_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 3D View: https://static.hansa.com/3D/44440173; Catalog Drawing URL: http://static.hansa.com/catdrw/44440173; Category B2B: Accessories; Category B2C: Shower solutions; Color variants: 4444017333;4444017380;4444017381; Dimension Drawing URL: http://static.hansa.com/dimdrw/44440173; FDV Document URL: http://www.hansa.com/datasheet/44440173/en/fdv; Group: Hand shower holder; Installation and Maintenance Guide URL: http://static.hansa.com/manual/44440173; Interactive AR View URL: https://static.hansa.com/AR/44440173; Manufacturer: HANSA; Market: Austria;Belgium;Switzerland;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/44440173; Model: 44440173 Hand shower holder; Name_en: 44440173 Hand shower holder; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 44440173; Product Family: HANSA; Product Image URL: http://static.hansa.com/image/44440173; Product URL: http://static.hansa.com/44440173; Spare-Part Information URL: http://static.hansa.com/sp/44440173; Technical DataSheet URL: http://www.hansa.com/datasheet/44440173/en; Type Name: 44440173 Hand shower holder; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Concealed Parts: Round rosette; Installation Type: Wall mounted; Shower Parts: Shower holder; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 44440173(2025); Features: n/a; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 44440173; Name: 44440173 Hand shower holder; ReplacementCost: n/a; Shape: Sculptured; Size: 150x100x150 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 44440173; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 44440173 Hand shower holder; Category: Plumbing Fixtures
Type - Pset_ValveTypeCommon - FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 44440173 Hand shower holder; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.014025 m2; Volume: 0.000315 m3
Identity Data - Mark: 4
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 44440173(2025): 44440173 Hand shower holder; Family and Type: 44440173(2025): 44440173 Hand shower holder; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 44440173(2025): 44440173 Hand shower holder; Type Id: 44440173(2025): 44440173 Hand shower holder; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
